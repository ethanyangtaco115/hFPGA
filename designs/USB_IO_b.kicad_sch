File: designs/USB_IO_b.kicad_sch (KiCad schematic)
At the start: 4 parts, among them U7 FT230XQ

Commit message: Add files via upload
Connections:
- net +3V3: no longer U7.9 (~{RESET})
